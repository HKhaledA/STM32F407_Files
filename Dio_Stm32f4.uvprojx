# Keil uVision project Dio_Stm32f4.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Dio_Stm32f4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MCAL
    ./: STM32F407_DIO.h STM32F407_DIO.c STD_TYPES.h STM32F407_Interrupt.c STM32F407_Interrupt.h CORE_STM32F407.h STM32F407_uC.h STM32F407_SPI.c STM32F407_SPI.h
  group ECUAL
    ./: LED.h LED.c
  group UserApp
    ./: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
